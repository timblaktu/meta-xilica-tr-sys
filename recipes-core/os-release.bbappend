# Customize content of /etc/os-release
#

OS_RELEASE_FIELDS:append = " XILICA_BUILD_TIMESTAMP"
XILICA_BUILD_TIMESTAMP = "lost somewhere in time"
